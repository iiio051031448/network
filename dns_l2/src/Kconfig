## dns_l2/src/Kconfig
```kconfig
config L2_SMART_DNS
	tristate "L2 Smart DNS"
	help
	  This is a L2 Smart DNS module.
```
